<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\TP_System_Micro_Lejars_Geslin_Laloux.ewp</path>
  </project>
  <batchBuild />
</workspace>
